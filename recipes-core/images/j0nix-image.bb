inherit core-image

IMAGE_INSTALL:append = " packagegroup-core-boot dropbear"
