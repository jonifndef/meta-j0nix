COMPATIBLE_MACHINE:append = "raspberrypi2"
